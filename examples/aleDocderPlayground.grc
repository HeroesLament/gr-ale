options:
  parameters:
    author: Sypher
    copyright: GPL v3
    description: This flow provides a very basic playground to feed an ALE-2G signal to the decoder, and visibly see the incoming signal with a waterfall and histogram display.
    generate_options: qt_gui
    id: aledecoderplayground
    output_language: python
    title: ALE Decoder Playground
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: waterfall_bw
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: ale_decode_ff_0
  id: ale_decode_ff
  parameters:
    freq: '0'
    wdir: ''
    wsec: '0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/sypher/Downloads/2G_ALEaudio.wav
    repeat: 'True'
  states: {}
- name: qtgui_grbackground_0
  id: qtgui_grbackground
  parameters: {}
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    update_time: '0.001'
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: waterfall_bw
    fc: '2000'
    fftsize: '32768'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: fff
  states: {}

connections:
- [blocks_float_to_complex_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', ale_decode_ff_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_complex_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_histogram_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
